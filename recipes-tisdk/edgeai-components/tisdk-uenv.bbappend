FILESEXTRAPATHS:edgeai := "${THISDIR}/${PN}/${MACHINE}/edgeai"
FILESEXTRAPATHS:adas := "${THISDIR}/${PN}/${MACHINE}/adas"

PR:append = "_edgeai_0"

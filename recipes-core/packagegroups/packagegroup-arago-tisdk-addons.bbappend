PR:append = "_edgeai_0"

DEMOS:remove:edgeai = "ti-apps-launcher"

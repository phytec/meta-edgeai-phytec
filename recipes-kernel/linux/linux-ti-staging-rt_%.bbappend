FILESEXTRAPATHS:prepend := "${THISDIR}/linux-ti-staging/${MACHINE}:"

PR:append = "_edgeai_0"

require rtos-mem-map.inc

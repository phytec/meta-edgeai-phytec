BOOTENV_OVERLAYS_APPEND += " k3-am68-phyboard-izar-vm016-mipi-csi0.dtbo k3-j721s2-edgeai-apps.dtbo"

# 0.6.2 release
SRCREV = "6e2e829f8810708638597d49a3a7c1f2eac28ba2"

PV = "0.6.2+git${SRCPV}"

PR:append = "_edgeai"


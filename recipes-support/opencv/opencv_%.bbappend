TOOLCHAIN_TARGET_TASK:append = " opencv-staticdev"
